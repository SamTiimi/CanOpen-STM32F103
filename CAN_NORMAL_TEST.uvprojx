# Keil uVision project CAN_NORMAL_TEST.uvprojx, settings and files
target CAN_NORMAL_TEST (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CAN_NORMAL_TEST +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Drivers\RTT;..\Drivers\CanopenNode_stm32;..\Drivers\CanopenNode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ./: startup_stm32f103xb.s
    ../Drivers/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Drivers/CanopenNode/: CANopen.c
    ../Core/Src/: main.c gpio.c can.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group CanopenNode_stm32
    ../Drivers/CanopenNode_stm32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c
  group CanopenNode/301
    ../Drivers/CanopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
  group CanopenNode_/309
    ../Drivers/CanopenNode/309/: CO_gateway_ascii.c
  group CanopenNode_/303
    ../Drivers/CanopenNode/303/: CO_LEDs.c
  group CanopenNode_/304
    ../Drivers/CanopenNode/304/: CO_GFC.c CO_SRDO.c
  group CanopenNode_/305
    ../Drivers/CanopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
software components: CMSIS:CORE 6.1.0
